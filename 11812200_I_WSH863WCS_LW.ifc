Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-05-03T09:32:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 03 09:32:05 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\5d4d8dfd-bd51-4f56-b23c-edbd341a5fd0\e6bec2c6-4174-4957-b782-cc105179ae49\ifc * Database version: 5507 * Database creation date: Tue May 03 09:32:04 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 03 09:32:05 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 03 09:32:05 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11812200_I_WSH863WCS_LW:11SH8631_I_11812200_WSH863WCS_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 11SH8631_I_11812200_WSH863WCS_LW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 11SH8631_I_11812200_WSH863WCS_LW
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 643 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_359867
Description: Flow; FlowDirection: SOURCEANDSINK
